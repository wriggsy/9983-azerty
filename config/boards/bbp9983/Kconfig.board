## config/boards/bbp9983/Kconfig.board
```kconfig
# Copyright (c) 2023 ZitaoTech
# SPDX-License-Identifier: MIT

config BOARD_BBP9983
    bool "bbp9983"
    depends on SOC_NRF52840_QIAA
```
